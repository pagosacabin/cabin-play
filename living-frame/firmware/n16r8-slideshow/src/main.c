/*
 * 0243 -- SD-card slideshow on the living frame (N16R8, MAC c4:9e:7e:08:6d:f4).
 *
 * One project, two apps, selected by build flag:
 *
 *   APP_STAGE=1  (env n16r8-slideshow-stage) -- copies the ten framebuffer
 *                rasters staged in the `frames` flash partition onto the card
 *                at /sdcard/FRAMES, then proves each file byte-for-byte by
 *                reading it back and comparing SHA-256 with the flash copy.
 *                The card is identity-gated first: nothing is written unless
 *                the seated card is 0241's SanDisk (CID PSN 0xc6bd0f92).
 *
 *   APP_STAGE=0  (env n16r8-slideshow) -- the slideshow itself: mounts the
 *                card with the 0239 fold (raw pre-sacrifice + one stock
 *                driver init), enumerates /sdcard/FRAMES sorted by name,
 *                streams each raster into the VGA framebuffer and advances
 *                every ~10 s, looping to the first frame after the last.
 *                No card / no valid frames -> the embedded hummingbird is
 *                displayed exactly as the accepted 0228 build does.
 *
 * Driver, pins, timings and the 800x600 mode are the accepted build's
 * (n16r8-photo, env n16r8-photo-800x600): 1 framebuffer byte = 1 DAC byte =
 * 1 output pixel, 8 bpp RGB222, 15-line bounce buffers, no_fb streaming.
 *
 * The FT232R console on this bench delivers nothing (0225), so every claim in
 * the report partition is written by this app and read back with esptool.
 * Only this app's own lines go in the report -- the IDF log is left to the
 * console so 0241's lesson (DEBUG/VERBOSE flooding the report buffer) cannot
 * recur.
 */
#include <stdio.h>
#include <stdarg.h>
#include <stdint.h>
#include <string.h>
#include <stdlib.h>
#include <errno.h>
#include <strings.h>
#include <inttypes.h>
#include <dirent.h>
#include <sys/stat.h>

#include "freertos/FreeRTOS.h"
#include "freertos/task.h"
#include "esp_heap_caps.h"
#include "esp_lcd_panel_rgb.h"
#include "esp_lcd_panel_ops.h"
#include "esp_timer.h"
#include "esp_partition.h"
#include "esp_flash.h"
#include "driver/spi_master.h"
#include "driver/gpio.h"
#include "driver/sdspi_host.h"
#include "sdmmc_cmd.h"
#include "esp_vfs_fat.h"
#include "soc/soc_caps.h"

#include "photo64_meta.h"
#include "photo64_data.h"   /* embedded fallback raster, generated by the converter */

#define TASK_NO "0243"

/* ---- scanout mode -------------------------------------------------------- */
#ifndef OUT_W
#define OUT_W 800
#endif
#ifndef OUT_H
#define OUT_H 600
#endif
#define FB_BYTES (OUT_W * OUT_H)

#ifndef PCLK_HZ
#define PCLK_HZ       40000000u
#endif
#ifndef H_SYNC_PW
#define H_SYNC_PW     128
#endif
#ifndef H_BACK_PORCH
#define H_BACK_PORCH  88
#endif
#ifndef H_FRONT_PORCH
#define H_FRONT_PORCH 40
#endif
#ifndef V_SYNC_PW
#define V_SYNC_PW     4
#endif
#ifndef V_BACK_PORCH
#define V_BACK_PORCH  23
#endif
#ifndef V_FRONT_PORCH
#define V_FRONT_PORCH 1
#endif
#ifndef BB_LINES
#define BB_LINES 15
#endif
#define BB_PX (OUT_W * BB_LINES)
#if (OUT_H % BB_LINES) != 0
#error "BB_LINES must divide OUT_H"
#endif

/* ---- SD (identical to 0229/0234/0239/0240/0241) -------------------------- */
#define PIN_SCK   12
#define PIN_MOSI  11
#define PIN_MISO  13
#define PIN_CS    10

#define SD_MOUNT_POINT "/sdcard"
#define FRAMES_DIR     "/sdcard/FRAMES"
#define FRAMES_PART    "frames"
#define MAX_FRAMES     32
#define FRAME_NAME_LEN 32

/* 0241's card, and the two identities this bench must never write. */
#define CARD_PSN_SD32G 0xc6bd0f92u
#define CARD_PSN_KIT   0x000013a4u
#define CARD_PSN_SR512 0xe4845e78u

/* ---- report sink ---------------------------------------------------------
 * The report partition is the log, but the panel streams from PSRAM through a
 * bounce ISR, and a flash erase (64 KiB, tens of ms) stalls the cache that ISR
 * reads PSRAM through -- the RGB FIFO underflows.  So the whole partition is
 * erased ONCE at boot, before the panel starts, and every later persist is a
 * single 4 KiB sector write with no erase (a few ms, inside the bounce
 * budget).  Each persist is a record: magic, length, text.  The reader walks
 * the sectors in order and prints the text of every valid record.
 * ------------------------------------------------------------------------- */
#define REPORT_SECTOR   4096
#define REPORT_SECTORS  16
#define REPORT_MAGIC    0x30323433u   /* "0243" */

static char  g_report[60000];
static size_t g_report_len;
static const esp_partition_t *s_report_part;
static int s_report_sector;

static void app_logf(const char *fmt, ...)
{
    char line[400];
    va_list ap;
    va_start(ap, fmt);
    int n = vsnprintf(line, sizeof(line), fmt, ap);
    va_end(ap);
    if (n < 0) return;
    fputs(line, stdout);
    if (n > (int)sizeof(line) - 1) n = (int)sizeof(line) - 1;
    if (g_report_len + (size_t)n < sizeof(g_report)) {
        memcpy(g_report + g_report_len, line, (size_t)n);
        g_report_len += (size_t)n;
    }
}

/* Open the log.  The partition is erased only when it does not already hold
 * 0243 records: an earlier boot's log (e.g. the stage run before this show run)
 * is kept and this run appends after it.  Called before the panel starts, so an
 * erase is safe here and only here. */
static void report_open(void)
{
    s_report_part = esp_partition_find_first(ESP_PARTITION_TYPE_DATA,
                                             (esp_partition_subtype_t)0x40, "report");
    s_report_sector = 0;
    if (s_report_part == NULL) return;

    uint32_t hdr[2] = {0, 0};
    if (esp_partition_read(s_report_part, 0, hdr, sizeof hdr) == ESP_OK &&
        hdr[0] == REPORT_MAGIC && hdr[1] > 0 && hdr[1] <= REPORT_SECTOR - 8) {
        while (s_report_sector < REPORT_SECTORS) {
            size_t addr = (size_t)s_report_sector * REPORT_SECTOR;
            if (esp_partition_read(s_report_part, addr, hdr, sizeof hdr) != ESP_OK) break;
            if (hdr[0] != REPORT_MAGIC || hdr[1] == 0 || hdr[1] > REPORT_SECTOR - 8) break;
            s_report_sector++;
        }
        app_logf("REPORT: continuing the existing log at sector %d\n", s_report_sector);
        return;
    }
    esp_partition_erase_range(s_report_part, 0, s_report_part->size);
}

/* Persist everything logged since the last flush, in 4 KiB records.  No erase. */
static void report_flush(void)
{
    if (s_report_part == NULL || g_report_len == 0) return;
    size_t off = 0;
    while (off < g_report_len && s_report_sector < REPORT_SECTORS) {
        size_t chunk = g_report_len - off;
        if (chunk > REPORT_SECTOR - 8) chunk = REPORT_SECTOR - 8;
        uint32_t hdr[2] = { REPORT_MAGIC, (uint32_t)chunk };
        size_t addr = (size_t)s_report_sector * REPORT_SECTOR;
        if (esp_partition_write(s_report_part, addr, hdr, sizeof hdr) != ESP_OK ||
            esp_partition_write(s_report_part, addr + sizeof hdr, g_report + off, chunk) != ESP_OK) {
            return;   /* a failed persist must not take the display down */
        }
        s_report_sector++;
        off += chunk;
    }
    if (off >= g_report_len) {
        g_report_len = 0;
    } else if (off > 0) {
        memmove(g_report, g_report + off, g_report_len - off);
        g_report_len -= off;
    }
    /* Out of sectors: keep logging in RAM; the earlier records still stand. */
}

/* ---- SHA-256 ------------------------------------------------------------
 * Software implementation, carried over verbatim from 0241: mbedtls' digest
 * came back with its first 8 bytes zeroed inside that build's card-I/O path,
 * and the digests here are the evidence, so the hash is computed by code whose
 * two known answers are checked at boot before any digest is quoted. */
typedef struct {
    uint32_t h[8];
    uint64_t total;
    uint8_t  blk[64];
    size_t   fill;
} sw_sha256_t;

static const uint32_t S256_K[64] = {
    0x428a2f98, 0x71374491, 0xb5c0fbcf, 0xe9b5dba5, 0x3956c25b, 0x59f111f1,
    0x923f82a4, 0xab1c5ed5, 0xd807aa98, 0x12835b01, 0x243185be, 0x550c7dc3,
    0x72be5d74, 0x80deb1fe, 0x9bdc06a7, 0xc19bf174, 0xe49b69c1, 0xefbe4786,
    0x0fc19dc6, 0x240ca1cc, 0x2de92c6f, 0x4a7484aa, 0x5cb0a9dc, 0x76f988da,
    0x983e5152, 0xa831c66d, 0xb00327c8, 0xbf597fc7, 0xc6e00bf3, 0xd5a79147,
    0x06ca6351, 0x14292967, 0x27b70a85, 0x2e1b2138, 0x4d2c6dfc, 0x53380d13,
    0x650a7354, 0x766a0abb, 0x81c2c92e, 0x92722c85, 0xa2bfe8a1, 0xa81a664b,
    0xc24b8b70, 0xc76c51a3, 0xd192e819, 0xd6990624, 0xf40e3585, 0x106aa070,
    0x19a4c116, 0x1e376c08, 0x2748774c, 0x34b0bcb5, 0x391c0cb3, 0x4ed8aa4a,
    0x5b9cca4f, 0x682e6ff3, 0x748f82ee, 0x78a5636f, 0x84c87814, 0x8cc70208,
    0x90befffa, 0xa4506ceb, 0xbef9a3f7, 0xc67178f2
};

static uint32_t s256_rotr(uint32_t x, int n) { return (x >> n) | (x << (32 - n)); }

static void s256_block(sw_sha256_t *s, const uint8_t *p)
{
    uint32_t w[64];
    for (int i = 0; i < 16; i++) {
        w[i] = ((uint32_t)p[i * 4] << 24) | ((uint32_t)p[i * 4 + 1] << 16) |
               ((uint32_t)p[i * 4 + 2] << 8) | (uint32_t)p[i * 4 + 3];
    }
    for (int i = 16; i < 64; i++) {
        uint32_t s0 = s256_rotr(w[i - 15], 7) ^ s256_rotr(w[i - 15], 18) ^ (w[i - 15] >> 3);
        uint32_t s1 = s256_rotr(w[i - 2], 17) ^ s256_rotr(w[i - 2], 19) ^ (w[i - 2] >> 10);
        w[i] = w[i - 16] + s0 + w[i - 7] + s1;
    }
    uint32_t a = s->h[0], b = s->h[1], c = s->h[2], d = s->h[3];
    uint32_t e = s->h[4], f = s->h[5], g = s->h[6], hh = s->h[7];
    for (int i = 0; i < 64; i++) {
        uint32_t S1 = s256_rotr(e, 6) ^ s256_rotr(e, 11) ^ s256_rotr(e, 25);
        uint32_t ch = (e & f) ^ ((~e) & g);
        uint32_t t1 = hh + S1 + ch + S256_K[i] + w[i];
        uint32_t S0 = s256_rotr(a, 2) ^ s256_rotr(a, 13) ^ s256_rotr(a, 22);
        uint32_t mj = (a & b) ^ (a & c) ^ (b & c);
        uint32_t t2 = S0 + mj;
        hh = g; g = f; f = e; e = d + t1;
        d = c; c = b; b = a; a = t1 + t2;
    }
    s->h[0] += a; s->h[1] += b; s->h[2] += c; s->h[3] += d;
    s->h[4] += e; s->h[5] += f; s->h[6] += g; s->h[7] += hh;
}

static void s256_init(sw_sha256_t *s)
{
    s->h[0] = 0x6a09e667; s->h[1] = 0xbb67ae85; s->h[2] = 0x3c6ef372; s->h[3] = 0xa54ff53a;
    s->h[4] = 0x510e527f; s->h[5] = 0x9b05688c; s->h[6] = 0x1f83d9ab; s->h[7] = 0x5be0cd19;
    s->total = 0; s->fill = 0;
}

static void s256_update(sw_sha256_t *s, const uint8_t *p, size_t n)
{
    s->total += n;
    while (n--) {
        s->blk[s->fill++] = *p++;
        if (s->fill == 64) { s256_block(s, s->blk); s->fill = 0; }
    }
}

static void s256_final(sw_sha256_t *s, uint8_t out[32])
{
    uint64_t bits = s->total * 8ull;
    uint8_t pad = 0x80;
    s256_update(s, &pad, 1);
    uint8_t z = 0;
    while (s->fill != 56) s256_update(s, &z, 1);
    uint8_t len[8];
    for (int i = 0; i < 8; i++) len[i] = (uint8_t)(bits >> (56 - 8 * i));
    s256_update(s, len, 8);
    for (int i = 0; i < 8; i++) {
        out[i * 4]     = (uint8_t)(s->h[i] >> 24);
        out[i * 4 + 1] = (uint8_t)(s->h[i] >> 16);
        out[i * 4 + 2] = (uint8_t)(s->h[i] >> 8);
        out[i * 4 + 3] = (uint8_t)(s->h[i]);
    }
}

static void sha256_hex(sw_sha256_t *s, char out[65])
{
    uint8_t d[32];
    s256_final(s, d);
    for (int i = 0; i < 32; i++) snprintf(out + i * 2, 3, "%02x", d[i]);
    out[64] = 0;
}

static void sha256_buf(const uint8_t *p, size_t n, char out[65])
{
    sw_sha256_t s;
    s256_init(&s);
    s256_update(&s, p, n);
    sha256_hex(&s, out);
}

/* Checked before any digest is quoted: "abc" and 480,000 zero bytes. */
static bool sha_kat(void)
{
    char h[65];
    sha256_buf((const uint8_t *)"abc", 3, h);
    if (strcmp(h, "ba7816bf8f01cfea414140de5dae2223b00361a396177a9cb410ff61f20015ad") != 0) {
        app_logf("SHA_KAT: FAIL on \"abc\": %s\n", h);
        return false;
    }
    /* 1 MiB of zeros in 4 KiB updates: a whole number of blocks, so the
     * expected digest cannot be off by a partial chunk. */
    static uint8_t z[4096];
    sw_sha256_t s;
    s256_init(&s);
    for (int i = 0; i < 256; i++) s256_update(&s, z, sizeof z);
    sha256_hex(&s, h);
    if (strcmp(h, "30e14955ebf1352266dc2ff8067e68104607e750abb9d3b36582b8af909fcb58") != 0) {
        app_logf("SHA_KAT: FAIL on 1 MiB of zeros: %s\n", h);
        return false;
    }
    app_logf("SHA_KAT: abc ok; 1 MiB of zeros ok\n");
    return true;
}

/* ---- SD: raw pre-sacrifice (0239) --------------------------------------- */
static const char *g_cmd_tag = "";
static bool g_raw_tx_err;

static uint8_t sd_crc7(const uint8_t *d, int n)
{
    uint8_t crc = 0;
    for (int k = 0; k < n; k++) {
        uint8_t b = d[k];
        for (int i = 0; i < 8; i++) {
            crc = (uint8_t)(crc << 1);
            if ((b & 0x80) ^ (crc & 0x80)) crc ^= 0x09;
            b = (uint8_t)(b << 1);
        }
    }
    return (uint8_t)((crc << 1) | 1);
}

static uint8_t sd_raw_cmd(spi_device_handle_t dev, uint8_t cmd, uint32_t arg,
                          int extra, uint8_t *out, int out_max)
{
    uint8_t tx[32], rx[32];
    memset(tx, 0xFF, sizeof tx);
    memset(rx, 0x00, sizeof rx);
    g_raw_tx_err = false;

    tx[0] = 0x40 | cmd;
    tx[1] = (uint8_t)(arg >> 24);
    tx[2] = (uint8_t)(arg >> 16);
    tx[3] = (uint8_t)(arg >> 8);
    tx[4] = (uint8_t)(arg);
    tx[5] = sd_crc7(tx, 5);

    int n = 6 + 8 + extra;
    if (n > (int)sizeof(tx)) n = (int)sizeof(tx);

    gpio_set_level(PIN_CS, 0);
    spi_transaction_t t = {0};
    t.length = (size_t)n * 8;
    t.tx_buffer = tx;
    t.rx_buffer = rx;
    esp_err_t err = spi_device_transmit(dev, &t);
    gpio_set_level(PIN_CS, 1);

    {
        uint8_t ff = 0xFF;
        spi_transaction_t tail = {0};
        tail.length = 8;
        tail.tx_buffer = &ff;
        if (spi_device_transmit(dev, &tail) != ESP_OK) g_raw_tx_err = true;
    }

    if (err != ESP_OK) {
        app_logf("    %sCMD%-2u: spi transfer failed (%s)\n", g_cmd_tag, cmd,
                 esp_err_to_name(err));
        g_raw_tx_err = true;
        return 0xFF;
    }

    int idx = -1;
    for (int i = 6; i < n; i++) {
        if ((rx[i] & 0x80) == 0) { idx = i; break; }
    }
    if (idx < 0) {
        app_logf("    %sCMD%-2u arg=0x%08" PRIx32 ": NO RESPONSE\n", g_cmd_tag, cmd, arg);
        return 0xFF;
    }
    int copied = 0;
    for (int i = idx + 1; i < n && copied < out_max && copied < extra; i++, copied++) {
        out[copied] = rx[i];
    }
    return rx[idx];
}

/* 74+ clocks with CS high, one throwaway CMD0, CS high, bus released so the
 * stock driver can initialise SPI2 itself.  Value and intent are 0239's; the
 * call is not skipped on a failed transfer (a failed frame is not a sacrifice). */
static esp_err_t fold_presacrifice(uint8_t *r1_out)
{
    *r1_out = 0xFF;
    app_logf("\n--- 0239 PRE-SACRIFICE (raw bus, before the driver) ---\n");

    spi_bus_config_t bus = {
        .mosi_io_num = PIN_MOSI,
        .miso_io_num = PIN_MISO,
        .sclk_io_num = PIN_SCK,
        .quadwp_io_num = -1,
        .quadhd_io_num = -1,
        .max_transfer_sz = 4096,
    };
    esp_err_t err = spi_bus_initialize(SPI2_HOST, &bus, SPI_DMA_CH_AUTO);
    if (err != ESP_OK) {
        app_logf("  SACRIFICE: spi_bus_initialize failed (%s) -- not counted\n",
                 esp_err_to_name(err));
        return err;
    }

    gpio_set_direction(PIN_CS, GPIO_MODE_OUTPUT);
    gpio_set_level(PIN_CS, 1);

    spi_device_interface_config_t devcfg = {0};
    devcfg.clock_speed_hz = 400 * 1000;
    devcfg.mode = 0;
    devcfg.spics_io_num = -1;
    devcfg.queue_size = 1;
    spi_device_handle_t dev = NULL;
    err = spi_bus_add_device(SPI2_HOST, &devcfg, &dev);
    if (err != ESP_OK) {
        app_logf("  SACRIFICE: add_device failed (%s) -- not counted\n", esp_err_to_name(err));
        spi_bus_free(SPI2_HOST);
        return err;
    }

    {
        uint8_t ff[10];
        memset(ff, 0xFF, sizeof ff);
        gpio_set_level(PIN_CS, 1);
        spi_transaction_t t = {0};
        t.length = sizeof(ff) * 8;
        t.tx_buffer = ff;
        err = spi_device_transmit(dev, &t);
    }
    if (err != ESP_OK) {
        app_logf("  SACRIFICE: dummy-clock transfer failed (%s) -- not counted\n",
                 esp_err_to_name(err));
        spi_bus_remove_device(dev);
        spi_bus_free(SPI2_HOST);
        return err;
    }

    uint8_t pl[8] = {0};
    g_cmd_tag = "SACRIFICE ";
    uint8_t r1 = sd_raw_cmd(dev, 0, 0x00000000, sizeof pl, pl, sizeof pl);
    g_cmd_tag = "";
    if (g_raw_tx_err) {
        app_logf("  SACRIFICE: CMD0 transfer failed -- not counted\n");
        gpio_set_level(PIN_CS, 1);
        spi_bus_remove_device(dev);
        spi_bus_free(SPI2_HOST);
        return ESP_FAIL;
    }
    gpio_set_level(PIN_CS, 1);
    spi_bus_remove_device(dev);
    spi_bus_free(SPI2_HOST);
    app_logf("  SACRIFICE: R1=0x%02x (discarded); bus released\n", r1);
    *r1_out = r1;
    return ESP_OK;
}

/* Mount with the stock driver at 400 kHz -- the clock, CS handling and
 * pull-ups are unchanged from the configuration 0241 proved. */
static bool card_mount(const char *tag, sdmmc_card_t **out)
{
    app_logf("\n--- SD MOUNT [%s] ---\n", tag);
    spi_bus_config_t bus = {
        .mosi_io_num = PIN_MOSI,
        .miso_io_num = PIN_MISO,
        .sclk_io_num = PIN_SCK,
        .quadwp_io_num = -1,
        .quadhd_io_num = -1,
        .max_transfer_sz = 4096,
    };
    esp_err_t err = spi_bus_initialize(SPI2_HOST, &bus, SPI_DMA_CH_AUTO);
    if (err != ESP_OK) {
        app_logf("  MOUNT_FAIL spi_bus_initialize=%s\n", esp_err_to_name(err));
        return false;
    }
    sdspi_device_config_t slot = SDSPI_DEVICE_CONFIG_DEFAULT();
    slot.host_id = SPI2_HOST;
    slot.gpio_cs = PIN_CS;

    sdmmc_host_t host = SDSPI_HOST_DEFAULT();
    host.slot = SPI2_HOST;
    host.max_freq_khz = 400;

    esp_vfs_fat_mount_config_t mcfg = {
        .format_if_mount_failed = false,
        .max_files = 4,
        .allocation_unit_size = 0,
    };
    sdmmc_card_t *card = NULL;
    err = esp_vfs_fat_sdspi_mount(SD_MOUNT_POINT, &host, &slot, &mcfg, &card);
    if (err != ESP_OK) {
        app_logf("  MOUNT_FAIL[%s]: %s (%d)\n", tag, esp_err_to_name(err), (int)err);
        spi_bus_free(SPI2_HOST);
        return false;
    }
    app_logf("  MOUNT_OK[%s]: card=%.*s psn=0x%08" PRIx32 " speed=%" PRIu32
             " kHz size=%llu MB\n",
             tag, 8, card->cid.name, (uint32_t)card->cid.serial, card->real_freq_khz,
             (unsigned long long)((uint64_t)card->csd.capacity * card->csd.sector_size
                                  / (1024 * 1024)));
    *out = card;
    return true;
}

static void card_unmount(sdmmc_card_t *card)
{
    esp_err_t err = esp_vfs_fat_sdcard_unmount(SD_MOUNT_POINT, card);
    app_logf("  UNMOUNT: %s\n", err == ESP_OK ? "ok" : esp_err_to_name(err));
    spi_bus_free(SPI2_HOST);
}

/* ---- scanout ------------------------------------------------------------- */
static uint8_t *s_fb[2];
static volatile int s_active;
static volatile uint32_t s_vsync_count;
static volatile uint32_t s_fill_count;

static bool IRAM_ATTR bounce_fill(esp_lcd_panel_handle_t panel, void *bounce_buf,
                                  int pos_px, int len_bytes, void *user_ctx)
{
    (void)panel; (void)user_ctx;
    s_fill_count++;
    memcpy(bounce_buf, s_fb[s_active] + pos_px, (size_t)len_bytes);
    return false;
}

static bool IRAM_ATTR on_vsync(esp_lcd_panel_handle_t panel,
                               const esp_lcd_rgb_panel_event_data_t *edata, void *user_ctx)
{
    (void)panel; (void)edata; (void)user_ctx;
    s_vsync_count++;
    return false;
}

static esp_err_t panel_start(esp_lcd_panel_handle_t *out_panel)
{
    esp_lcd_rgb_panel_config_t cfg = {
        .clk_src = LCD_CLK_SRC_PLL160M,
        .timings = {
            .pclk_hz = PCLK_HZ,
            .h_res = OUT_W,
            .v_res = OUT_H,
            .hsync_pulse_width = H_SYNC_PW,
            .hsync_back_porch = H_BACK_PORCH,
            .hsync_front_porch = H_FRONT_PORCH,
            .vsync_pulse_width = V_SYNC_PW,
            .vsync_back_porch = V_BACK_PORCH,
            .vsync_front_porch = V_FRONT_PORCH,
            .flags = { .hsync_idle_low = 1, .vsync_idle_low = 1, .pclk_active_neg = 1 },
        },
        .data_width = 8,
        .bits_per_pixel = 8,
        .num_fbs = 0,
        .bounce_buffer_size_px = BB_PX,
        .hsync_gpio_num = 17,
        .vsync_gpio_num = 18,
        .de_gpio_num = -1,
        .pclk_gpio_num = -1,
        .disp_gpio_num = -1,
        .flags = { .no_fb = 1 },
    };
    for (int i = 0; i < SOC_LCDCAM_RGB_DATA_WIDTH; i++) cfg.data_gpio_nums[i] = -1;
    cfg.data_gpio_nums[0] = 5;   /* R LSB */
    cfg.data_gpio_nums[1] = 4;   /* R MSB */
    cfg.data_gpio_nums[2] = 7;   /* G LSB */
    cfg.data_gpio_nums[3] = 6;   /* G MSB */
    cfg.data_gpio_nums[4] = 16;  /* B LSB */
    cfg.data_gpio_nums[5] = 15;  /* B MSB */

    esp_err_t err = esp_lcd_new_rgb_panel(&cfg, out_panel);
    if (err != ESP_OK) {
        app_logf("panel step 1 (new_rgb_panel) failed: %s\n", esp_err_to_name(err));
        return err;
    }
    esp_lcd_rgb_panel_event_callbacks_t cbs = {};
    cbs.on_bounce_empty = bounce_fill;
    cbs.on_vsync = on_vsync;
    err = esp_lcd_rgb_panel_register_event_callbacks(*out_panel, &cbs, NULL);
    if (err != ESP_OK) {
        app_logf("panel step 2 (register callbacks) failed: %s\n", esp_err_to_name(err));
        return err;
    }
    err = esp_lcd_panel_init(*out_panel);
    if (err != ESP_OK) app_logf("panel step 3 (panel_init) failed: %s\n", esp_err_to_name(err));
    return err;
}

/* ---- frame files --------------------------------------------------------- */
typedef struct {
    char name[FRAME_NAME_LEN];
    uint32_t size;
} frame_t;

static int frame_cmp(const void *a, const void *b)
{
    return strcmp(((const frame_t *)a)->name, ((const frame_t *)b)->name);
}

/* Enumerate /sdcard/FRAMES, keep *.BIN, sort by filename. */
static int frames_scan(frame_t *out, int max)
{
    DIR *d = opendir(FRAMES_DIR);
    if (!d) {
        app_logf("  SCAN: opendir(%s) failed (errno %d)\n", FRAMES_DIR, errno);
        return 0;
    }
    int n = 0, skipped = 0;
    struct dirent *e;
    while ((e = readdir(d)) != NULL) {
        size_t len = strlen(e->d_name);
        if (len < 4 || len >= FRAME_NAME_LEN || strcasecmp(e->d_name + len - 4, ".BIN") != 0)
            continue;
        if (e->d_name[0] == '.') continue;
        if (n >= max) { skipped++; continue; }
        char path[FRAME_NAME_LEN + 16];
        snprintf(path, sizeof path, "%s/%.*s", FRAMES_DIR, FRAME_NAME_LEN - 1, e->d_name);
        struct stat st;
        if (stat(path, &st) != 0) { skipped++; continue; }
        snprintf(out[n].name, sizeof out[n].name, "%.*s", FRAME_NAME_LEN - 1, e->d_name);
        out[n].size = (uint32_t)st.st_size;
        app_logf("  FILE %s %u B\n", out[n].name, (unsigned)out[n].size);
        n++;
    }
    closedir(d);
    qsort(out, (size_t)n, sizeof out[0], frame_cmp);
    app_logf("  SCAN: %d frame file(s) in %s%s%s\n", n, FRAMES_DIR,
             skipped ? ", " : "", skipped ? "some skipped" : "");
    return n;
}

/* Read one frame file into dst.  Returns true only if the whole file arrived
 * and its length is exactly one framebuffer. */
static bool frame_load(const frame_t *fr, uint8_t *dst, uint32_t *got, uint32_t *ms,
                       char sha[65])
{
    int64_t t0 = esp_timer_get_time();
    *got = 0;
    char path[160];
    snprintf(path, sizeof path, "%s/%s", FRAMES_DIR, fr->name);
    FILE *f = NULL;
    sw_sha256_t s;
    size_t total = 0;
    size_t r2 = 0;
    int ierr = 0;
    /* A short/zero first read off this card is a retryable I/O result, not a
     * verdict on the file: 0243's first run lost FRAME01.BIN to a 0-byte first
     * fread that a second open read fine.  One retry, logged, then decide. */
    for (int attempt = 0; attempt < 3; attempt++) {
        if (attempt) {
            app_logf("  RETRY %s: first read returned %u B (errno %d)\n", fr->name,
                     (unsigned)total, ierr);
            vTaskDelay(pdMS_TO_TICKS(100));
        }
        total = 0;
        ierr = 0;
        f = fopen(path, "rb");
        if (!f) {
            app_logf("  SKIP %s: open failed (errno %d)\n", fr->name, errno);
            return false;
        }
        s256_init(&s);
        for (;;) {
            size_t want = FB_BYTES - total;
            if (want > 32768) want = 32768;
            size_t r = fread(dst + total, 1, want, f);
            if (r == 0) { ierr = errno; break; }
            s256_update(&s, dst + total, r);
            total += r;
            if (total >= FB_BYTES) break;
        }
        /* Anything past FB_BYTES makes this a wrong-size file, not a frame. */
        uint8_t extra;
        r2 = fread(&extra, 1, 1, f);
        fclose(f);
        if (total == FB_BYTES) break;
    }
    *ms = (uint32_t)((esp_timer_get_time() - t0) / 1000);

    if (total != FB_BYTES || r2 != 0) {
        app_logf("  SKIP %s: %u B read%s, framebuffer is %d B\n", fr->name,
                 (unsigned)total, r2 ? " with trailing bytes" : "", FB_BYTES);
        return false;
    }
    sha256_hex(&s, sha);
    *got = (uint32_t)total;
    return true;
}

/* =========================================================================
 * STAGE -- flash partition -> card
 * ========================================================================= */
#ifdef APP_STAGE

static uint8_t s_io[32768];

static bool stage_one(const esp_partition_t *part, int i, const char *name)
{
    char path[160];
    snprintf(path, sizeof path, "%s/%s", FRAMES_DIR, name);
    FILE *f = fopen(path, "wb");
    if (!f) {
        app_logf("  STAGE_OPEN_FAIL %s (errno %d)\n", path, errno);
        return false;
    }
    sw_sha256_t sw;
    s256_init(&sw);
    size_t off = (size_t)i * FB_BYTES;
    size_t written = 0;
    int64_t t0 = esp_timer_get_time();
    while (written < FB_BYTES) {
        size_t want = FB_BYTES - written;
        if (want > sizeof s_io) want = sizeof s_io;
        esp_err_t err = esp_partition_read(part, off + written, s_io, want);
        if (err != ESP_OK) {
            app_logf("  STAGE_FLASH_READ_FAIL %s at %u: %s\n", name,
                     (unsigned)(off + written), esp_err_to_name(err));
            fclose(f);
            return false;
        }
        s256_update(&sw, s_io, want);
        if (fwrite(s_io, 1, want, f) != want) {
            app_logf("  STAGE_WRITE_FAIL %s at %u (errno %d)\n", name,
                     (unsigned)written, errno);
            fclose(f);
            return false;
        }
        written += want;
    }
    fflush(f);
    fclose(f);
    uint32_t wms = (uint32_t)((esp_timer_get_time() - t0) / 1000);
    char flash_sha[65];
    sha256_hex(&sw, flash_sha);

    /* Read it back from the card and compare digests. */
    t0 = esp_timer_get_time();
    f = fopen(path, "rb");
    if (!f) {
        app_logf("  STAGE_READBACK_OPEN_FAIL %s (errno %d)\n", name, errno);
        return false;
    }
    sw_sha256_t sr;
    s256_init(&sr);
    size_t rd = 0;
    for (;;) {
        size_t r = fread(s_io, 1, sizeof s_io, f);
        if (r == 0) break;
        s256_update(&sr, s_io, r);
        rd += r;
    }
    fclose(f);
    uint32_t rms = (uint32_t)((esp_timer_get_time() - t0) / 1000);
    char card_sha[65];
    sha256_hex(&sr, card_sha);

    bool ok = (rd == FB_BYTES) && strcmp(flash_sha, card_sha) == 0;
    app_logf("STAGE %s: wrote %u B in %u ms, read back %u B in %u ms, sha %s %s\n",
             name, (unsigned)written, (unsigned)wms, (unsigned)rd, (unsigned)rms,
             card_sha, ok ? "MATCH" : "MISMATCH");
    return ok;
}

static void stage_main(void)
{
    report_open();
    app_logf("\n########## 0243 STAGE: frames -> /sdcard/FRAMES ##########\n");
    app_logf("build: %s %s\n", __DATE__, __TIME__);
    if (!sha_kat()) { report_flush(); abort(); }

    const esp_partition_t *part = esp_partition_find_first(
        ESP_PARTITION_TYPE_DATA, (esp_partition_subtype_t)0x41, FRAMES_PART);
    if (part == NULL) {
        app_logf("FATAL: no '%s' data partition in the table\n", FRAMES_PART);
        report_flush();
        abort();
    }
    app_logf("frames partition: %s @ 0x%" PRIx32 ", %" PRIu32 " B (%d frames of %d B)\n",
             part->label, (uint32_t)part->address, (uint32_t)part->size,
             (int)(part->size / FB_BYTES), FB_BYTES);

    int nframes = (int)(part->size / FB_BYTES);
    if (nframes > 10) nframes = 10;   /* the card holds the ten this task staged */
    if (nframes <= 0) {
        app_logf("FATAL: partition holds no whole frame\n");
        report_flush();
        abort();
    }

    uint8_t r1 = 0xFF;
    if (fold_presacrifice(&r1) != ESP_OK) {
        app_logf("PARKED: pre-sacrifice failed; not mounting, not writing\n");
        report_flush();
        abort();
    }

    sdmmc_card_t *card = NULL;
    if (!card_mount("stage", &card)) {
        app_logf("PARKED: mount failed; nothing written\n");
        report_flush();
        abort();
    }

    /* Identity gate: only 0241's card.  Every other card -- the 1 GB kit card,
     * the 512 GB Recalbox SR512, anything unknown -- stops the run here. */
    uint32_t psn = (uint32_t)card->cid.serial;
    uint64_t cap_mb = (uint64_t)card->csd.capacity * card->csd.sector_size / (1024 * 1024);
    bool psn_ok  = (psn == CARD_PSN_SD32G);
    bool name_ok = (memcmp(card->cid.name, "SD32G", 5) == 0);
    bool cap_ok  = (cap_mb >= 28000 && cap_mb <= 34000);
    bool is_kit  = (psn == CARD_PSN_KIT);
    bool is_recalbox = (psn == CARD_PSN_SR512) || (cap_mb >= 400 * 1024);
    app_logf("CARD_ID: name=%.*s psn=0x%08" PRIx32 " capacity=%llu MB\n",
             8, card->cid.name, psn, (unsigned long long)cap_mb);
    app_logf("GATE_TESTS: psn_0241=%d name_SD32G=%d capacity_28_34GB=%d is_kit=%d "
             "is_recalbox=%d\n", (int)psn_ok, (int)name_ok, (int)cap_ok, (int)is_kit,
             (int)is_recalbox);
    if (!(psn_ok && name_ok && cap_ok) || is_kit || is_recalbox) {
        app_logf("GATE: REFUSED -- not unambiguously 0241's SanDisk (expect psn 0x%08" PRIx32
                 ", name SD32G, ~30436 MB). Nothing written.\n", CARD_PSN_SD32G);
        report_flush();
        card_unmount(card);
        abort();
    }
    app_logf("GATE: AUTHORIZED -- 0241's SanDisk (psn + CID name + capacity agree); "
             "writing only %s/\n", FRAMES_DIR);

    struct stat st;
    if (stat("/sdcard/NEWCARD.BIN", &st) == 0) {
        app_logf("PRESENT: /sdcard/NEWCARD.BIN %d B (0241 evidence, left untouched)\n",
                 (int)st.st_size);
    } else {
        app_logf("NOTE: /sdcard/NEWCARD.BIN not found (errno %d)\n", errno);
    }

    if (stat(FRAMES_DIR, &st) != 0) {
        if (mkdir(FRAMES_DIR, 0777) != 0) {
            app_logf("FATAL: mkdir %s failed (errno %d)\n", FRAMES_DIR, errno);
            report_flush();
            card_unmount(card);
            abort();
        }
        app_logf("MKDIR %s: created\n", FRAMES_DIR);
    } else {
        app_logf("MKDIR %s: already present\n", FRAMES_DIR);
    }

    int ok = 0;
    int64_t t0 = esp_timer_get_time();
    for (int i = 0; i < nframes; i++) {
        char name[FRAME_NAME_LEN];
        snprintf(name, sizeof name, "FRAME%02d.BIN", i + 1);
        if (stage_one(part, i, name)) ok++;
    }
    app_logf("STAGE_SUMMARY: %d/%d files written and verified in %.1f s\n", ok, nframes,
             (double)(esp_timer_get_time() - t0) / 1e6);

    /* Directory listing from the card, and NEWCARD.BIN still intact. */
    frame_t fr[MAX_FRAMES];
    int n = frames_scan(fr, MAX_FRAMES);
    for (int i = 0; i < n; i++) app_logf("  DIR %s %u B\n", fr[i].name, fr[i].size);
    if (stat("/sdcard/NEWCARD.BIN", &st) == 0) {
        app_logf("PRESENT_AFTER: /sdcard/NEWCARD.BIN %d B\n", (int)st.st_size);
    } else {
        app_logf("PRESENT_AFTER: /sdcard/NEWCARD.BIN MISSING (errno %d)\n", errno);
    }
    report_flush();
    card_unmount(card);
    app_logf("STAGE: done; board halted (this build does not display)\n");
    report_flush();
    for (;;) vTaskDelay(pdMS_TO_TICKS(1000));
}

#endif /* APP_STAGE */

/* =========================================================================
 * SLIDESHOW
 * ========================================================================= */
#ifndef APP_STAGE

#define DWELL_MS 15000   /* 0250 rung 2: 15 s so a probe can settle */

static void fb_alloc(void)
{
    for (int i = 0; i < 2; i++) {
        s_fb[i] = (uint8_t *)heap_caps_malloc(FB_BYTES, MALLOC_CAP_SPIRAM | MALLOC_CAP_8BIT);
        if (!s_fb[i]) {
            app_logf("FATAL: no PSRAM for framebuffer %d\n", i);
            report_flush();
            abort();
        }
    }
    app_logf("framebuffers: %p / %p, %d B each in PSRAM (integrity %s)\n",
             (void *)s_fb[0], (void *)s_fb[1], FB_BYTES,
             heap_caps_check_integrity(MALLOC_CAP_SPIRAM, true) ? "ok" : "FAIL");
}

static void show_embedded(const char *why)
{
    memcpy(s_fb[0], PHOTO64_IMAGE, FB_BYTES);
    s_active = 0;
    char h[65];
    sha256_buf(s_fb[0], FB_BYTES, h);
    app_logf("FALLBACK: %s -- showing the embedded hummingbird\n", why);
    app_logf("FALLBACK_SHA: runtime %s\n", h);
    app_logf("FALLBACK_SHA: tool    %s %s\n", PHOTO64_SHA256,
             strcmp(h, PHOTO64_SHA256) == 0 ? "MATCH" : "MISMATCH");
}

static void slideshow_main(void)
{
    report_open();
    app_logf("\n########## 0243 SLIDESHOW ##########\n");
    app_logf("build      : %s %s\n", __DATE__, __TIME__);
    app_logf("mode       : %dx%d, 1 fb byte = 1 DAC byte = 1 pixel, %d s dwell\n",
             OUT_W, OUT_H, DWELL_MS / 1000);
    app_logf("fallback   : embedded %s raster (%s), converter tools/convert_photo64.py\n",
             PHOTO64_MODE, PHOTO64_SPACE);
    if (!sha_kat()) { report_flush(); abort(); }
    if (sizeof(PHOTO64_IMAGE) != FB_BYTES) {
        app_logf("FATAL: embedded raster is %u B, framebuffer needs %d B\n",
                 (unsigned)sizeof(PHOTO64_IMAGE), FB_BYTES);
        report_flush();
        abort();
    }

    fb_alloc();

    /* Pre-state: what is on the card before anything is touched. */
    uint8_t r1 = 0xFF;
    bool mounted = false;
    sdmmc_card_t *card = NULL;
    frame_t fr[MAX_FRAMES];
    int nfr = 0;
    int first = -1;
    uint32_t first_bytes = 0, first_ms = 0;
    char first_sha[65] = {0};

    /* 0250 rung 2: this card's first init is intermittent (INVALID_CRC 265), so
     * fold and retry exactly as the live firmware does -- fold before every
     * attempt, up to six of them. */
    bool mret = false;
    for (int a = 1; a <= 6 && !mret; a++) {
        uint8_t rr = 0xFF;
        if (fold_presacrifice(&rr) == ESP_OK && card_mount("show", &card)) {
            mret = true;
            r1 = rr;
        } else {
            app_logf("MOUNT attempt %d failed, retrying\n", a);
            vTaskDelay(pdMS_TO_TICKS(250));
        }
    }
    if (mret) {
        mounted = true;
        struct stat st;
        if (stat("/sdcard/NEWCARD.BIN", &st) == 0)
            app_logf("CARD: /sdcard/NEWCARD.BIN %d B (0241 evidence)\n", (int)st.st_size);
        nfr = frames_scan(fr, MAX_FRAMES);
        /* Skip forward over any file that will not load, logging each skip. */
        for (int i = 0; i < nfr && first < 0; i++) {
            if (frame_load(&fr[i], s_fb[0], &first_bytes, &first_ms, first_sha)) first = i;
        }
    } else {
        app_logf("CARD: not available (mount failed) -- fallback path\n");
    }

    if (first < 0) {
        show_embedded(mounted ? "no loadable frame on the card" : "card not mounted");
    } else {
        s_active = 0;
        app_logf("FRAME seq=1 idx=%d %s: %u B read in %u ms, sha %.16s\n",
                 first + 1, fr[first].name, (unsigned)first_bytes, (unsigned)first_ms,
                 first_sha);
        app_logf("PLAY: %d frame(s), order %s .. %s\n", nfr, nfr ? fr[0].name : "-",
                 nfr ? fr[nfr - 1].name : "-");
    }

    esp_lcd_panel_handle_t panel = NULL;
    esp_err_t perr = panel_start(&panel);
    if (perr != ESP_OK) {
        app_logf("FATAL: panel start failed: %s\n", esp_err_to_name(perr));
        report_flush();
        abort();
    }
    app_logf("panel: streaming (no_fb, %d-line bounce buffers, %d B each)\n", BB_LINES, BB_PX);
    report_flush();

    int cur = (first >= 0) ? first : -1;
    int64_t t_start = esp_timer_get_time();
    int seq = (first >= 0) ? 1 : 0;

    for (;;) {
        if (cur < 0 || nfr <= 0) {
            vTaskDelay(pdMS_TO_TICKS(1000));
            continue;
        }
        int64_t t0 = esp_timer_get_time();

        /* Prefetch the next loadable frame into the other buffer while this one
         * is on screen: at the proven 400 kHz the read costs ~10 s, so it has
         * to overlap the dwell or every step would take twice as long. */
        int next = -1;
        uint32_t nbytes = 0, nms = 0;
        char nsha[65] = {0};
        for (int k = 1; k <= nfr; k++) {
            int cand = (cur + k) % nfr;
            if (cand == cur && k > 1) break;
            if (frame_load(&fr[cand], s_fb[1 - s_active], &nbytes, &nms, nsha)) {
                next = cand;
                break;
            }
            if (k >= nfr) break;
        }

        int64_t dwell_deadline = t0 + (int64_t)DWELL_MS * 1000;
        while (esp_timer_get_time() < dwell_deadline) {
            vTaskDelay(pdMS_TO_TICKS(20));
        }

        if (next < 0) {
            app_logf("LOOP_STALL: no loadable frame after %s; holding it\n", fr[cur].name);
            report_flush();
            vTaskDelay(pdMS_TO_TICKS(5000));
            continue;
        }

        /* 0250 rung 2: a short black gap between frames so the sequence is
         * countable on screen -- black, then the next colour, every 15 s. */
        memset(s_fb[s_active], 0x00, FB_BYTES);
        vTaskDelay(pdMS_TO_TICKS(800));
        s_active = 1 - s_active;      /* pointer swap; DMA picks it up next bounce */
        cur = next;
        seq++;
        int64_t t1 = esp_timer_get_time();
        app_logf("FRAME seq=%d %s: %u B (read %u ms), shown at %.3f s, step %.3f s, sha %.16s\n",
                 seq, fr[cur].name, (unsigned)nbytes, (unsigned)nms,
                 (double)(t1 - t_start) / 1e6, (double)(t1 - t0) / 1e6, nsha);
        /* The log lives in RAM while the panel streams: a report write erases
         * and rewrites 60 kB of flash, which disables the cache the bounce
         * ISR depends on.  Persist once per full loop (and on the wrap) so the
         * screen is not disturbed on every step. */
        if (seq == nfr + 1 || seq % nfr == 0) report_flush();
    }
}

#endif /* !APP_STAGE */

void app_main(void)
{
#ifdef APP_STAGE
    stage_main();
#else
    slideshow_main();
#endif
}
